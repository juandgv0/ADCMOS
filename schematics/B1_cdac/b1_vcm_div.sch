v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {devices/ipin.sym} -40 -40 0 0 {name=p1 lab=VREF



}
C {devices/ipin.sym} -40 -10 0 0 {name=p2 lab=VSS}
C {devices/opin.sym} 70 -30 0 0 {name=p3 lab=VCM}
C {sky130_fd_pr/res_xhigh_po_0p69.sym} 0 -80 0 0 {name=R1
L=0.69
model=res_xhigh_po_0p69
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p69.sym} 0 0 0 0 {name=R2
L=0.69
model=res_xhigh_po_0p69
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p69.sym} 0 90 0 0 {name=R3
L=0.69
model=res_xhigh_po_0p69
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p69.sym} 0 180 0 0 {name=R4
L=0.69
model=res_xhigh_po_0p69
spiceprefix=X
mult=1}
